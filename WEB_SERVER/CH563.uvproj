# Keil uVision project CH563.uvproj, settings and files
target CH563 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARM966E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM966E-S)
  output: CH563 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=1
  c include: ..\WEB_SERVER;..\..\SRC;..\PUB
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT5: ROM 0x10000 size 0x10000
  scatter file: ..\..\SRC\CH563D64.SCF
  group user
    ../../SRC/: ISPXT56X.O
    ./: HTTPS.C main.C
    ../PUB/: CH563NET_keil4.lib
  group sys
    ../../SRC/: SYSFREQ.C STARTUP.S
